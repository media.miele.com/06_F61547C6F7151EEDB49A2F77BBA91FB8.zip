Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-29T14:19:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 29 14:19:03 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\fe938f7a-f11f-4612-8695-510d2aca77a9\30705ae7-d975-4253-a01a-d59b0d833052\ifc * Database version: 5507 * Database creation date: Wed Mar 29 14:19:03 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 29 14:19:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 29 14:19:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11388370_CDN_G7566SCViXXL_OS-CS:21756662_CDN_11388370_G7566SCViXXL_OS-CS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 21756662_CDN_11388370_G7566SCViXXL_OS-CS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 21756662_CDN_11388370_G7566SCViXXL_OS-CS
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 855 mm; Depth: 550 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_357483
Description: Flow; FlowDirection: SOURCEANDSINK
